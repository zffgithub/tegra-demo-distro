inherit cuda

