inherit cuda

TARGET_CFLAGS += "-Wno-format-security"

