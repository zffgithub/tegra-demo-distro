# ROS_BUILDTOOL_DEPENDS += " \
#     ament-cmake-auto-native \
# "
# # EXTRA_OECMAKE += "-Dament_cmake_auto_DIR=${STAGING_DIR_HOST}/usr/share/ament_cmake_auto/cmake"