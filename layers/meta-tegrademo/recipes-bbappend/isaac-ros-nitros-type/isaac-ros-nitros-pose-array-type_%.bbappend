inherit fix-ros