ROS_BUILDTOOL_DEPENDS += " \
    ament-cmake-auto-native \
    rosidl-default-generators-native \
"

ROS_BUILD_DEPENDS += " \
    rosidl-runtime-c \
    rosidl-typesupport-introspection-cpp-native \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-c \   
"