inherit cuda
